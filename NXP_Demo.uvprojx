# Keil uVision project NXP_Demo.uvprojx, settings and files
target NXP_Lab_Demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.12.2.0
  cpu: CPUTYPE("Cortex-M7") FPU3(DFPU)
  output: NXP_Demo.out
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE=1, XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, DEBUG, CPU_MIMXRT1052DVL6B, PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1
  c misc: --library_interface=armcc 
--diag_suppress=66,1296,186 
--diag_suppress=1296,186
  c include: ..\NXP_Lab_Demo;.\CMSIS\Include;.\Device\board;.\Device\drivers\Lab_RT1052;.\Device\drivers\MIMXRT1052;.\Device\drivers\MIMXRT1052\camera;.\Device\startup\iar;.\Device\utilities;.\Device\xip;.\Application\myDriver;.\Application;.\Application\Control
  asm define: NDEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT4: ROM 0x200000 size 0x18000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\Download_Algorithm\MIMXRT1052xxxxx_flexspi_nor_sdram.scf
  link misc: --remove 
--keep=*(.boot_hdr.ivt) 
--keep=*(.boot_hdr.boot_data) 
--keep=*(.boot_hdr.dcd_data) 
--keep=*(.boot_hdr.conf) 
--predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group source
    ./Application/: irq.c main.c
    ./Application/myDriver/: bsp.c FinSH_driver.c ringbuffer.c
    ./Application/Control/: MotorCtrl.c QS_PID.c LowPassFilter.c ServoCtrl.c ImageProcess.c
  group board
    ./Device/board/: board.c clock_config.c pin_mux.c
  group Lab
    ./Device/drivers/Lab_RT1052/: Lab_GPIO.c Lab_LED.c Lab_KEY.c Lab_UART.c Lab_PWM.c Lab_12864SPI.c Lab_Encoder.c Lab_IIC.c Lab_CSI.c Lab_MT9V034M.c Lab_Camera.c
  group drivers
    ./Device/drivers/MIMXRT1052/: fsl_clock.c fsl_gpio.c fsl_lpuart.c fsl_common.c fsl_pwm.c fsl_enc.c fsl_xbara.c fsl_csi.c fsl_lpi2c.c
    ./Device/drivers/MIMXRT1052/camera/: fsl_sccb.c fsl_csi_camera_adapter.c
  group startup
    ./Device/startup/arm/: startup_MIMXRT1052.s
    ./Device/: system_MIMXRT1052.c
  group utilities
    ./Device/utilities/: serial_port_uart.c lpuart_adapter.c fsl_str.c fsl_debug_console.c fsl_assert.c serial_manager.c
  group xip
    ./Device/xip/: xip_config.c fsl_flexspi_nor_boot.c
  group doc
    ./: Readme.md
software components: RTOS:kernel 3.1.3, RTOS:shell 3.1.3
